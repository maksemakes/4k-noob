# Repository maksemakes/4k-noob

## KiCad design pcb tings/pcb tings.kicad_pcb

Parts:
C1, C2: 22pF; C_0805_2012Metric
C3: 1uF; C_0805_2012Metric
C4, C5, C6: 0.1uF; C_0805_2012Metric
C7: 10uF; C_0805_2012Metric
D1, D2, D3, D4: SOD-123; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2, MX3, MX4: MX-NoLED; MX-1U-NoLED
R1, R4: 10k; R_0805_2012Metric
R2, R3: 22; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-A; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, F1.1, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), MX3.1 (COL), U1.29 (PB5)
COL1: MX2.1 (COL), MX4.1 (COL), U1.28 (PB4)
D+: R2.2, USB1.3 (D+)
D-: R3.2, USB1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1 (GND), Y1.2, Y1.4
unnamed: C1.1, U1.17 (XTAL1), Y1.1
unnamed: C2.1, U1.16 (XTAL2), Y1.3
unnamed: C3.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.2, U1.33 (~HWB/PE2)
ROW0: D1.1 (K), D2.1 (K), U1.27 (PD7)
ROW1: D3.1 (K), D4.1 (K), U1.30 (PB6)
VCC: F1.2, USB1.5 (VBUS)

Board: 2 copper layers, 77.0 x 38.1 mm, 24 parts (20 on the bottom side), 20 nets.

## Commit log

2022-07-13 lets go rin :)
2022-07-13 added submodules
2022-07-13 building schem
2022-08-24 Finally back to working on this
2022-08-24 completed MCU zone
2022-08-24 power
2022-08-31 Added the footprints to the schema (the software needs to know the shape of the components) Here are a few links. Dont connect the shield on the USB to anything. https://forum.arduino.cc/t/where-do-y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
    and we should be go to go to create the PCB and start the layout itself.
2022-09-06 finished assigning foot prints
2022-09-06 started working on pcb layout
2022-09-06 creating pcb
2022-09-08 creating pcb edge cuts
2022-09-17 completing the component placements.
2022-09-27 PCB work and updating ignore file
2022-09-27 final push
2022-09-27 Merge branch 'master' of https://github.com/maksemakes/4k-noob into rin_branch
    # Conflicts:
    # pcb tings/pcb tings.kicad_pcb
    # pcb tings/pcb tings.kicad_sch
2022-09-27 Fixed footprints and edgecuts
2022-09-30 fixed connections (ratsnest)
2022-09-30 Routing
2022-09-30 fill zones (check for "unconnected" error)
2022-10-11 fixed USB connection error DRC
